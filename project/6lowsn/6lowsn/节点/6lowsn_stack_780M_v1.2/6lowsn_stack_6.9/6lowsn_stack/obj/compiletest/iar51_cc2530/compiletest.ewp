# IAR project compiletest.ewp, settings and files
configuration coord (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x51; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_COORDINATOR; LOWSN_USE_DEMO_STATIC_BIND
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\SRC\STACK\; ..\..\..\SRC\STACK\TARGET\IAR51\CC2530\
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2530b.xcl
configuration rfd (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x53; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_SENSOR_TYPE=1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2530.xcl
configuration router (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x52; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_ROUTER; LOWSN_USE_DEMO_STATIC_BIND
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2530.xcl
configuration edge_coord (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x51; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_COORDINATOR; LOWSN_SLIP_TO_HOST
  group (top)
    ../../../src/simpletests/: test_demo.c
  group board
    ../../../src/stack/target/iar51/cc2430_evb/: evbConfig.h evboard.c
  group hal
    ../../../src/stack/target/iar51/cc2530/: compiler.h hal.h hal_board_cfg.h hal_dma.c hal_dma.h halHeapSpace.h halNeighbor.c halStack.c
  group stack
    ../../../src/stack/: 6lowsn.h 6lowsn_common_types.h 6lowsn_config.h adp.c adp.h aps.c aps.h console.c console.h debug.c debug.h ds.c ds.h evboard.h halStack.h icmpv6.c icmpv6.h ieee_lrwpan_defs.h mac.c mac.h memalloc.c memalloc.h mp.c mp.h nd.c nd.h neighbor.c neighbor.h nwk.c nwk.h phy.c phy.h slip.c slip.h
