# IAR project Backup of compiletest.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\chipcon\CC2430.i51
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\; ..\..\..\src\stack\; ..\..\..\src\stack\target\iar51\cc2430_31\
  ICC8051.CCDefines: DEBUG
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2430_8K.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\INC\
  ICC8051.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew.xcl
configuration coord (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x51; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_COORDINATOR; LOWSN_USE_DEMO_STATIC_BIND
configuration rfd (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x53; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00
configuration router (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x52; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_ROUTER; LOWSN_USE_DEMO_STATIC_BIND
  group (top)
    ../../../src/simpletests/: test_pingpong.c
  group board
    ../../../src/stack/target/iar51/cc2430_evb/: evbConfig.h evboard.c
  group hal
    ../../../src/stack/target/iar51/cc2430_31/: compiler.h hal.h halHeapSpace.h halNeighbor.c halStack.c
  group stack
    ../../../src/stack/: 6lowsn.h 6lowsn_common_types.h 6lowsn_config.h adp.c adp.h aps.c aps.h console.c console.h debug.c debug.h ds.c ds.h evboard.h halStack.h icmpv6.c icmpv6.h ieee_lrwpan_defs.h mac.c mac.h memalloc.c memalloc.h nd.c nd.h neighbor.c neighbor.h nwk.c nwk.h phy.c phy.h staticbind.c staticbind.h zep.c zep.h
