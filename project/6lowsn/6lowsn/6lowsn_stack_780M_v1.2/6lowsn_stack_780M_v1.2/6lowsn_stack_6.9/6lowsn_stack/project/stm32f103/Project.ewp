# IAR project Project.ewp, settings and files
configuration STM3210B-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rfd (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x76; aExtendedAddress_B6=0x78; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_SENSOR_TYPE=1; USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\src\stack; ..\..\src\stack\target\stm32\common; ..\..\src\stack\target\stm32\stm32f103_evb; ..\..\src\stack\target\stm32\driver\inc
configuration router (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x01; aExtendedAddress_B6=0x79; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_ROUTER; LOWSN_USE_DEMO_STATIC_BIND; USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: as above
configuration coord (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x51; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_COORDINATOR; LOWSN_USE_DEMO_STATIC_BIND; USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
configuration edge_coord (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LOWSN_DEBUG; aExtendedAddress_B7=0x00; aExtendedAddress_B6=0x00; aExtendedAddress_B5=0x50; aExtendedAddress_B4=0x40; aExtendedAddress_B3=0x30; aExtendedAddress_B2=0x20; aExtendedAddress_B1=0x10; aExtendedAddress_B0=0x00; LOWSN_COORDINATOR; LOWSN_SLIP_TO_HOST; USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 0
  group apps
    ../../src/apps/: test_demo.c
  group stack
    ../../src/stack/: 6lowsn.h 6lowsn_common_types.h 6lowsn_config.h adp.c adp.h aps.c aps.h console.c console.h debug.c debug.h ds.c ds.h icmpv6.c icmpv6.h ieee_lrwpan_defs.h mac.c mac.h memalloc.c memalloc.h mp.c mp.h nd.c nd.h neighbor.c neighbor.h nwk.c nwk.h phy.c phy.h slip.c slip.h
  group target/stm32/common
    ../../src/stack/target/stm32/common/: compiler.h core_cm3.c core_cm3.h hal.h halHeapSpace.h halNeighbor.c halStack.c halstack.h startup_stm32f10x_md.s stm32f10x_conf.h stm32f10x_it.c system_stm32f10x.c
  group target/stm32/driver
    ../../src/stack/target/stm32/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group target/stm32/stm32f103_evb
    ../../src/stack/target/stm32/stm32f103_evb/: _STM32F107_Console.c _STM32F107_Console.h AT86RF212.c AT86RF212.h cc1101_spi.c cc1101_spi.h stm3210b_eval.c
